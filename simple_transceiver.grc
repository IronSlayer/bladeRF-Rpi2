<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simple_transceiver</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>2.42e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>d</value></param>
</block>
<block>
<key>gr_probe_signal_f</key>
<param><key>id</key><value>raw_mag_sqrd_probe</value></param>
</block>
<block>
<key>gr_message_source</key>
<param><key>id</key><value>message_source</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>device</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>raw_mag_sqrd</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_gmsk_demod</key>
<param><key>id</key><value>demod</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>gr_message_sink</key>
<param><key>id</key><value>message_sink</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>dont_block</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>decoder</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>avg_mag_probe</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>0.001</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>device</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>blks2_gmsk_mod</key>
<param><key>id</key><value>modulator</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>encoder</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<connection><source_block_id>demod</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder</source_block_id><sink_block_id>message_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>raw_mag_sqrd</source_block_id><sink_block_id>raw_mag_sqrd_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>message_source</source_block_id><sink_block_id>encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>encoder</source_block_id><sink_block_id>modulator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulator</source_block_id><sink_block_id>uhd_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_source</source_block_id><sink_block_id>demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_source</source_block_id><sink_block_id>avg_mag_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_source</source_block_id><sink_block_id>raw_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
